# Copyright (C) 2014 NEO-Technologies
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-kernel/linux/linux-rockchip-3.0.inc

COMPATIBLE_MACHINE = "(rk3188)"
